# Keil uVision project led_blinky.uvprojx, settings and files
target IK-52840DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52840_qiaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 SOFTDEVICE_PRESENT BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\boards;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\integration\nrfx;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\delay;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\memobj;..\..\components\libraries\balloc;..\..\components\libraries\ringbuf;..\..\components\libraries\atomic;..\..\external\fprintf;..\..\external\segger_rtt;..\..\integration\nrfx\legacy;..\..\modules\nrfx\drivers\src;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\drivers\src\prs;..\..\external\freertos\config;..\..\external\freertos\portable\ARM\nrf52;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\components\softdevice\s140\headers\nrf52;..\..\components\softdevice\s140\headers;..\..\components\softdevice\common;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\integration\nrfx;..\..\components\libraries\util;..\..\components\libraries\experimental_section_vars;..\..\components\drivers_nrf\twi_master\deprecated;..\..\components\drivers_nrf\twi_master\deprecated\config;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\drivers\src;..\..\integration\nrfx\legacy;..\..\integration\nrfx;..\..\app\mpu6050;..\..\app\task_service;..\..\components\libraries\uart;..\..\components\libraries\fifo;..\..\app\mpu6050\DMP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../app/: main.c
    ../config/: sdk_config.h
    ../../external/freertos/config/: FreeRTOSConfig.h
  group Board Definition
    ../../components/boards/: boards.c
  group Board_Drivers
    ../../app/mpu6050/: mpu6050.c
    ../../app/task_service/: task_service.c
  group nRF_Drivers
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../modules/nrfx/drivers/src/: nrfx_spi.c nrfx_spim.c nrfx_uart.c nrfx_uarte.c nrfx_clock.c nrfx_twi_twim.c nrfx_twim.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_twi.c nrf_drv_uart.c
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/drivers_nrf/twi_master/deprecated/: twi_sw_master.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c app_error_handler_keil.c app_error_weak.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group FreeRTOS
    ../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../external/freertos/portable/ARM/nrf52/: port.c
    ../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Mpu_eMPL
    ../../app/mpu6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
